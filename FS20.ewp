# IAR project FS20.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX128xxx7 Freescale MK20DX128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: FS20.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Includes
    ./: config.h drivers.h FlexSound20.h mae.h messages.h mxtos.h simple_gain_mod.h streams.h
  group Sources
    ./: FlexSound20.c FS20.c mae_config.c mae_drivers.c mae_func_table.c mae_msg_queue.c mae_queue.c main.c simple_gain_mod.c
